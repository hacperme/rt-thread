# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32U545xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\io\poll; ..\..\..\components\finsh; ..\libraries\HAL_Drivers\drivers; ..\..\..\components\drivers\include; ..\..\..\libcpu\arm\cortex-m33; ..\..\..\components\libc\compilers\common\extension; board\CubeMX_Config\Inc; ..\libraries\STM32U5xx_HAL\STM32U5xx_HAL_Driver\Inc; ..\..\..\components\libc\posix\ipc; ..\libraries\HAL_Drivers\CMSIS\Include; .; board; ..\..\..\components\drivers\spi; ..\libraries\HAL_Drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; applications; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\components\mprotect; ..\..\..\components\libc\posix\io\eventfd; ..\libraries\STM32U5xx_HAL\CMSIS\Device\ST\STM32U5xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/iar/: startup_stm32u545xx.s
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c mpu.c syscall_iar.S trustzone.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart.c stm32u5xx_hal.c stm32u5xx_hal_spi.c stm32u5xx_hal_crc.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_usart.c stm32u5xx_hal_pwr.c stm32u5xx_hal_rcc.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rng.c stm32u5xx_hal_tim.c stm32u5xx_hal_cortex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_cryp.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_lptim.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
  group mprotect
    ../../../components/mprotect/examples/: mprotect_example_ro_data.c mprotect_example_exclusive_region.c mprotect_example_exception_hook.c
    ../../../components/mprotect/: mprotect.c
