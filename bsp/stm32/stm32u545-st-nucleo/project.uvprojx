# Keil uVision project project.uvprojx, settings and files
target rtthread (6220000::V6.22::ARMCLANG)
  device: STM32U545RETx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: project
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/arm/: startup_stm32u545xx.s
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c mpu.c syscall_rvds.S trustzone.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_usart.c stm32u5xx_hal_lptim.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_adc.c stm32u5xx_hal_pwr.c stm32u5xx_hal.c stm32u5xx_hal_spi.c stm32u5xx_hal_comp.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_gpio.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_dma.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_crc.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
  group mprotect
    ../../../components/mprotect/examples/: mprotect_example_exception_hook.c mprotect_example_ro_data.c mprotect_example_exclusive_region.c
    ../../../components/mprotect/: mprotect.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/syslog/: syslog.c
