# Keil uVision project template.uvprojx, settings and files
target rtthread (6140000::V6.14::ARMCLANG)
  device: STM32U545RETx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: .\board\linker_scripts\link.sct
